# IAR project C2_Example.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5502 MSP430F5502
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; EL073_Core_Lib
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5502.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; F5xx_F6xx_Core_Lib
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: DELAY.C E6_73.c main.c
